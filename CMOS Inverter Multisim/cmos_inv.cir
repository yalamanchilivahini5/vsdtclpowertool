** cmos_inv **
*
* NI Multisim to SPICE Netlist Export
* Generated by: VAHINI
* Thu, Jun 18, 2020 17:09:49
*

*## Multisim Component C1 ##*
* !!!BEGIN-INTERACT
*  : delay_factor ++++i2   ;
*  : setval       ++++f4   ;
*  : ratedval     ++++f6   ;
*  : init_cond    ++++f8   ;
*  0          constant  S_OK
*  1e-15      VARIABLE  capblown
*  0.0        VARIABLE  flag
*  0.0        VARIABLE  r1Cur
*  0.0        VARIABLE  c1Voltage
*  0.0        VARIABLE  resistance
*  0          VARIABLE  cnt
*  1          VARIABLE  delaytime
*  0          VARIABLE  S_BLOWN
*
* : DELAY
*  *delaytime  0 do
*          *cnt 1+ ==>_*cnt
*          *cnt *delaytime =  if
*          *S_BLOWN 1 + ==>_*S_BLOWN
*          0 ==>_*cnt
*          endif
*   loop
*   *S_BLOWN ==>_*animation_state
* ;
*
* : RESET
*       delay_factor 10000 * ==>_*delaytime
*       0.0 ==>_*flag
*       0.0 ==>_*c1Voltage
*       0.0 ==>_*r1Cur
*       1e15 ==>_*resistance
*       S_OK   ==>_*animation_state
*       0 ==>_*S_BLOWN
* ;
*
*  :BEGIN_PLOT
*         RESET
*  ;
*
*  : C_BLOWN
*      *capblown  resistance   GRADUAL_CHANGE_AT_RUN
*  ;
*
*  :GRADUAL_CHANGE_AT_RUN locals| ref value |
*     value     SET_INSTANCE Resistor ::R r1 resistance
*  ;
*
*  :OUT_DATA
*   1.0 *flag f.> if
*     GET_INSTANCE Resistor ::R r1  i  ==>_*r1Cur
*     *r1Cur f.abs 1e30 f.* ==>_*c1Voltage
*     ratedval *c1Voltage f.< if
*          1.0 ==>_*flag
*          DELAY
*          DELAY
*          DELAY
*          DELAY
*          DELAY
*          C_BLOWN
*     endif
*   endif
*  ;
*
* :BEGIN_ANALYSIS
*     RESET
* ;
*
* !!!END-INTERACT
xC1 OUT 0 virtual_capC1
.subckt virtual_capC1 1 2
r1 1 2 1e30
c1 1 2 1e-015  IC=0
.ends

*## Multisim Component pmos_def ##*
mpmos_def OUT IN VDD VDD PMOS__TRANSISTORS_VIRTUAL__1__1  L=1.8e-007  W=2e-007

*## Multisim Component nmos_def ##*
mnmos_def OUT IN 0 0 NMOS__TRANSISTORS_VIRTUAL__1__1  L=1.8e-007  W=1e-007

*## Multisim Component V1 ##*
vV1 IN 0 ac 0 0
+   distof1 0 0
+   distof2 0 0
+   pulse(0 1.8 0 1e-009 1e-009 1e-008 2e-008)

*## Multisim Component VDD ##*
VDDVDD  VDD 0 dc 1.8

.model PMOS__TRANSISTORS_VIRTUAL__1__1 pmos
+ (
+  Level=3 VTO=0 KP=2e-005 GAMMA=0 PHI=0.6 CBD=0 CBS=0 IS=1e-014
+  PB=0.8 CGSO=0 CGDO=0 CGBO=0 CJ=0 MJ=0.5 CJSW=0 MJSW=0.33 JS=0
+  TOX=4e-009 LD=0 U0=600 FC=0.5 XJ=0 XD=0 KAPPA=0.2 L=1.8e-007
+  W=2e-007
+ )

.model NMOS__TRANSISTORS_VIRTUAL__1__1   nmos
+ (
+  Level=3 VTO=0 KP=2e-005 GAMMA=0 PHI=0.6 CBD=0 CBS=0 IS=1e-014
+  PB=0.8 CGSO=0 CGDO=0 CGBO=0 CJ=0 MJ=0.5 CJSW=0 MJSW=0.33 JS=0
+  TOX=4e-009 LD=0 U0=600 FC=0.5 XJ=0 XD=0 KAPPA=0.2 L=1.8e-007
+  W=1e-007
+ )
